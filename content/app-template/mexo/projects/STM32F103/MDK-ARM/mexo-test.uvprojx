# Keil uVision project mexo-test.uvprojx, settings and files
target mexo-test (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: mexo-test +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;         ../Drivers/STM32F1xx_HAL_Driver/Inc;         ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;         ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;         ../Drivers/CMSIS/Include;         ../../../../reference/robosd-ref;         ../../../../reference/robosd-ref/core/platform/keil+cpp6;         ../../../source/common;         ../../../source/platform/stm32F103;         ../../../source/common/vercion/test
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group source/common
    ../../../source/common/: mexo-test.cpp mexo-test.hpp
  group source/platform
    ../../../source/platform/stm32F103/: robosd_app_tuning.hpp mexo-test-perephery.cpp
  group robosd++/core
    E:/SOURCETREE/robosd++/content/app-template/reference/robosd-ref/core/: robosd_common.hpp robosd_delegat.hpp robosd_lambda.hpp robosd_list.hpp robosd_log.cpp robosd_log.hpp robosd_ring.hpp robosd_ring_buf.hpp robosd_string.cpp robosd_string.hpp robosd_system.cpp robosd_system.hpp
  group robosd++/core/platform
    E:/SOURCETREE/robosd++/content/app-template/reference/robosd-ref/core/platform/keil+cpp6/: robosd_target.hpp
  group robosd++/mexo
    ../../../../reference/robosd-ref/mexo/: mexo.cpp mexo.h mexo.hpp led.hpp math.hpp
software components: CMSIS:CORE 5.4.0
