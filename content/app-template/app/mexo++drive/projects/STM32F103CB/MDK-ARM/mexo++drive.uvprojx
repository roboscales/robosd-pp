# Keil uVision project mexo++drive.uvprojx, settings and files
target mexo++drive (6160000::V6.16::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: mexo++drive-number-test +hex
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6, MPPD_DRIVE_NUMBER_TEST
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../../../../reference/robosd-ref;../../../../../reference/robosd-ref/core/platform/keil+cpp6;../../../source/common;..\..\..\source\platform\STM32F103CB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group robosd++
    ../../../../../reference/robosd-ref/core/: robosd_string.cpp robosd_string.hpp robosd_common.hpp robosd_system.cpp robosd_system.hpp robosd_system_weak.cpp robosd_log.cpp robosd_log.hpp
  group mexo++
    ../../../../../reference/robosd-ref/mexo++/: mexo_common.hpp mexo.cpp mexo.h mexo.hpp mexo_math.hpp dev.front.hpp led.hpp
  group common
    ../../../source/common/: mexo++drive.common.hpp mexo++drive.cpp mexo++drive.hpp mexo++drive.names.hpp mexo++drive.unittest.cpp
  group platform
    ../../../source/platform/STM32F103CB/: robosd_app_tuning.hpp mexo++drive-103cb.prf.cpp
  group common/tunning
    ../../../source/common/tunning/: numbertest.tuning.hpp
  group robosd++/prf
    ../../../../../reference/robosd-ref/prf/: clock_ns.hpp
software components: CMSIS:CORE 5.6.0
