# Keil uVision project mexo-test.uvprojx, settings and files
target mexo-test (6160000::V6.16::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: mexo-test +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,STM32F405xx
  c misc: -mfpu=fpv4-sp-d16 -mfloat-abi=hard
  c include: ../Core/Inc;         ../../../../../reference/robosd-ref;         ../../../../../reference/robosd-ref/core/platform/keil+cpp6;         ../../../source/common;         ..\..\..\source\platform\STM32F405-omega;         ../../../source/common/vercion/test;         ../Drivers/STM32F4xx_HAL_Driver/Inc;         ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;         ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;         ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group source/common
    ../../../source/common/: mexo-test.cpp mexo-test.hpp mexo-model-test.cpp
  group source/platform
    ../../../source/platform/STM32F405-omega/: mexo-test-perephery.cpp robosd_app_tuning.hpp
  group robosd++/core
    ../../../../../reference/robosd-ref/core/: robosd_common.hpp robosd_delegat.hpp robosd_lambda.hpp robosd_list.hpp robosd_log.cpp robosd_log.hpp robosd_ring.hpp robosd_ring_buf.hpp robosd_string.cpp robosd_string.hpp robosd_system.cpp robosd_system.hpp
  group robosd++/core/platform
    ../../../../../reference/robosd-ref/core/platform/keil+cpp6/: robosd_target.hpp
  group robosd++/mexo
    ../../../../../reference/robosd-ref/mexo/: mexo.cpp mexo.h mexo.hpp led.hpp math.hpp ps.hpp adc.hpp regulator.hpp actuator.inc.hpp ps.inc.hpp enco.hpp motion.templ.settings.inc.hpp positioner.templ.settings.inc.hpp
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ./: startup_stm32f405xx.s
    ../Core/Src/: system_stm32f4xx.c
  group robosd++/net
    ../../../../../reference/robosd-ref/net/: robosd_flow.cpp robosd_flow.hpp robosd_flow_id.h robosd_ring_buf.hpp robosd_serial.cpp robosd_serial.hpp
  group robosd++/fm
    ../../../../../reference/robosd-ref/freemaster/: robosd_fm.cpp robosd_fm.hpp
  group robosd++/prf/AS5048A
    ../../../../../reference/robosd-ref/prf/AS5048A/: as5048a.hpp
software components: CMSIS:CORE 5.4.0
